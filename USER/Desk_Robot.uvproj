# Keil uVision project Desk_Robot.uvproj, settings and files
target Desk_Robot (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Desk_Robot +hex
  c flags: Optim=1
  c define: rvmdk PART_TM4C123GH6PM  TARGET_IS_TM4C123_RA3 ARM_MATH_CM4 __FPU_PRESENT __TARGET_FPU_SOFTVFP
  c include: ..\include_now;..\uC-Library_files;..\uC-CPU_files;..\uCOS-II_files\Ports;..\uCOS-II_files\Source;D:\TI\TivaWare_C_Series-2.1.0.12573;D:\TI\TivaWare_C_Series-2.1.0.12573\inc;D:\TI\TivaWare_C_Series-2.1.0.12573\driverlib;..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ../APP/: app.c app_hooks.c app_task.c
  group DEAL
    ../DEAL/: LED.c LEDBuffer.c keytouch.c motor.c Bluetooth.c alldata_deal.c
  group DRIVE
    ../APP/: all_init.c mem_Store.c mem_Q.c api_mem.c
    ../DRIVE/: i2c_3731.c I2C_vl53l0x.c timer.c
    D:/TI/TivaWare_C_Series-2.1.0.12573/driverlib/rvmdk/: driverlib.lib
    ./: startup_TM4C123.s
  group OS_SOURCE
    ../uCOS-II_files/Source/: os.h os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group OS_PORT
    ../uCOS-II_files/Ports/: os_cpu_c.c os_cpu_a.asm os_dbg.c os_cpu.h
  group Readme
    ./: Readme.txt
